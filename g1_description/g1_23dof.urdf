Commit message: Remove origin from floating base

File: g1_description/g1_23dof.urdf (robot description, URDF)
Before this commit: robot g1_23dof, 49 links, 48 joints
Joints:
- joint dummy: origin xyz=0.0 0.0 -0.03 rpy=0 0 0 -> (none)
